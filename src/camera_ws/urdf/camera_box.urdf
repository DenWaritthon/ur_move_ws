Commit message: readmepls

File: src/camera_ws/urdf/camera_box.urdf (robot description, URDF)
Before this commit: robot camera_box, 1 links, 0 joints
Links:
- link camera_link: geometry collision box size=0.5 0.5 0.05; visual box size=0.5 0.5 0.05
